# Keil uVision project RC522.uvprojx, settings and files
target rc522 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC522
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\cmsis;.\CMSIS\STM32F4xx_StdPeriph_Driver\inc;.\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./CMSIS/cmsis/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group user
    ./user/src/: beep.c delay.c led.c main.c malloc.c motor.c rc522.c spi.c systick_delay.c uart.c dma.c time.c key.c adc.c
  group driver
    ./CMSIS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_fsmc.c stm32f4xx_gpio.c
